<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_decode</key>
<param><key>id</key><value>advoqpsk_advoqpsk_decode_0</value></param>
<param><key>ifDebug</key><value>False</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_divider</key>
<param><key>id</key><value>advoqpsk_advoqpsk_divider_0</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_powerstep</key>
<param><key>id</key><value>advoqpsk_advoqpsk_powerstep_0</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_precfofix</key>
<param><key>id</key><value>advoqpsk_advoqpsk_precfofix_0</value></param>
<param><key>cfoin</key><value>250</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_precfofix</key>
<param><key>id</key><value>advoqpsk_advoqpsk_precfofix_0_0_0</value></param>
<param><key>cfoin</key><value>83</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_sync</key>
<param><key>id</key><value>advoqpsk_advoqpsk_sync_0</value></param>
<param><key>ccThreshold</key><value>threshold</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_trigger</key>
<param><key>id</key><value>advoqpsk_advoqpsk_trigger_0</value></param>
<param><key>ccThreshold</key><value>threshold*0.8</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_trigger</key>
<param><key>id</key><value>advoqpsk_advoqpsk_trigger_0_0</value></param>
<param><key>ccThreshold</key><value>threshold*0.8</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_trigger</key>
<param><key>id</key><value>advoqpsk_advoqpsk_trigger_0_1</value></param>
<param><key>ccThreshold</key><value>threshold*0.8</value></param>
</block>
<block>
<key>advoqpsk_advoqpsk_trigger</key>
<param><key>id</key><value>advoqpsk_advoqpsk_trigger_0_2</value></param>
<param><key>ccThreshold</key><value>threshold*0.8</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor</key>
<param><key>id</key><value>blocks_ctrlport_monitor_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/cloud/advTf_30_100</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_length</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>8081</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate/2</value></param>
<param><key>center_freq0</key><value>2405e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0.3</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>start_time</key><value>-1</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>advoqpsk_advoqpsk_decode_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_divider_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_divider_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_precfofix_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_divider_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_precfofix_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_divider_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_divider_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_powerstep_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_powerstep_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_sync_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_powerstep_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_powerstep_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_powerstep_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_powerstep_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_precfofix_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_precfofix_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_precfofix_0_0_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_precfofix_0_0_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_trigger_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_sync_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_decode_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_sync_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_decode_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_trigger_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_sync_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_trigger_0_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_sync_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_trigger_0_1</source_block_id><sink_block_id>advoqpsk_advoqpsk_sync_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>advoqpsk_advoqpsk_trigger_0_2</source_block_id><sink_block_id>advoqpsk_advoqpsk_sync_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_divider_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>advoqpsk_advoqpsk_divider_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
