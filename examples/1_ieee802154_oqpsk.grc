options:
  parameters:
    category: '[IEEE802.15.4]'
    generate_options: hb
    id: ieee802_15_4_oqpsk_phy
    output_language: python
    title: IEEE802.15.4 OQPSK PHY
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: advoqpsk_chiptosym_1
  id: advoqpsk_chiptosym
  parameters: {}
  states: {}
- name: advoqpsk_decode_0
  id: advoqpsk_decode
  parameters:
    ifDebug: 'False'
  states: {}
- name: advoqpsk_divider_0
  id: advoqpsk_divider
  parameters: {}
  states: {}
- name: advoqpsk_powerstep_0
  id: advoqpsk_powerstep
  parameters: {}
  states: {}
- name: advoqpsk_precfofix_0
  id: advoqpsk_precfofix
  parameters:
    cfoin: '250'
  states: {}
- name: advoqpsk_precfofix_1
  id: advoqpsk_precfofix
  parameters:
    cfoin: '83'
  states: {}
- name: advoqpsk_prefixer_0
  id: advoqpsk_prefixer
  parameters: {}
  states: {}
- name: advoqpsk_sync_0
  id: advoqpsk_sync
  parameters:
    ccThreshold: threshold
  states: {}
- name: advoqpsk_trigger_0
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: advoqpsk_trigger_1
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: advoqpsk_trigger_2
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: advoqpsk_trigger_3
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    minoutbuf: 2**16
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '128'
    lengthtagname: packet_len
    minoutbuf: 2**16
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0, sin(pi/4), 1, sin(3*pi/4)]'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '16'
    in_type: byte
    out_type: complex
    symbol_table: '[(1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (1-1j), (-1+1j), (1+1j), (-1-1j), (-1-1j), (1+1j), (-1+1j), (-1+1j), (-1-1j), (1-1j), (-1-1j), (1-1j), (1+1j), (1-1j), (1+1j), (-1+1j), (1+1j), (-1-1j), (1-1j), (-1+1j), (-1+1j), (1-1j), (-1-1j), (-1-1j), (-1+1j), (1+1j), (-1+1j), (1+1j), (1-1j), (1+1j), (1-1j), (-1-1j)]'
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {state: disabled}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '0'
    pad_tail: '8'
  states: {}
- name: ieee802_15_4_access_code_prefixer_0
  id: ieee802_15_4_access_code_prefixer
  parameters:
    pad: '0x00'
    preamble: '0x000000a7'
  states: {state: disabled}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: note_0
  id: note
  parameters:
    note: lower nipple is sent first
  states: {}
- name: note_1
  id: note
  parameters:
    note: maps chunks of 4 bis directly to qpsk symbols
  states: {}
- name: note_2
  id: note
  parameters:
    note: half sine pulse shape
  states: {}
- name: note_3
  id: note
  parameters:
    note: 4 samples per (chip) symbol
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: txout
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: rxout
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: rxin
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: txin
    optional: 'True'
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {state: disabled}

connections:
- [advoqpsk_chiptosym_1, '0', blocks_repeat_0, '0']
- [advoqpsk_decode_0, out, pad_sink_1, in]
- [advoqpsk_divider_0, '0', advoqpsk_decode_0, '0']
- [advoqpsk_divider_0, '0', advoqpsk_precfofix_0, '0']
- [advoqpsk_divider_0, '0', advoqpsk_precfofix_1, '0']
- [advoqpsk_divider_0, '0', advoqpsk_sync_0, '0']
- [advoqpsk_divider_0, '1', advoqpsk_powerstep_0, '0']
- [advoqpsk_powerstep_0, '0', advoqpsk_sync_0, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_0, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_1, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_2, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_3, '1']
- [advoqpsk_precfofix_0, '0', advoqpsk_trigger_0, '0']
- [advoqpsk_precfofix_0, '1', advoqpsk_trigger_1, '0']
- [advoqpsk_precfofix_1, '0', advoqpsk_trigger_2, '0']
- [advoqpsk_precfofix_1, '1', advoqpsk_trigger_3, '0']
- [advoqpsk_prefixer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [advoqpsk_sync_0, '0', advoqpsk_decode_0, '1']
- [advoqpsk_sync_0, '1', advoqpsk_decode_0, '2']
- [advoqpsk_trigger_0, '0', advoqpsk_sync_0, '2']
- [advoqpsk_trigger_1, '0', advoqpsk_sync_0, '3']
- [advoqpsk_trigger_2, '0', advoqpsk_sync_0, '4']
- [advoqpsk_trigger_3, '0', advoqpsk_sync_0, '5']
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_tag_gate_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', advoqpsk_chiptosym_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_tag_gate_0, '0', blocks_float_to_complex_0, '1']
- [blocks_tagged_stream_multiply_length_0, '0', foo_packet_pad2_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [foo_packet_pad2_0, '0', blocks_complex_to_float_0, '0']
- [ieee802_15_4_access_code_prefixer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_15_4_packet_sink_0, out, pad_sink_1, in]
- [pad_source_0, '0', advoqpsk_divider_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [pad_source_1, out, advoqpsk_prefixer_0, in]
- [pad_source_1, out, ieee802_15_4_access_code_prefixer_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
