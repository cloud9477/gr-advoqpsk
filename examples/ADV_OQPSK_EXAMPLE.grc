options:
  parameters:
    generate_options: qt_gui
    id: ADV_OQPSK_EXAMPLE
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: threshold
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: advoqpsk_decode_0
  id: advoqpsk_decode
  parameters:
    ifDebug: 'True'
  states: {}
- name: advoqpsk_divider_0
  id: advoqpsk_divider
  parameters: {}
  states: {}
- name: advoqpsk_powerstep_0
  id: advoqpsk_powerstep
  parameters: {}
  states: {}
- name: advoqpsk_precfofix_0
  id: advoqpsk_precfofix
  parameters:
    cfoin: '250'
  states: {}
- name: advoqpsk_precfofix_1
  id: advoqpsk_precfofix
  parameters:
    cfoin: '83'
  states: {}
- name: advoqpsk_sync_0
  id: advoqpsk_sync
  parameters:
    ccThreshold: threshold
  states: {}
- name: advoqpsk_trigger_0
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: advoqpsk_trigger_1
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: advoqpsk_trigger_2
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: advoqpsk_trigger_3
  id: advoqpsk_trigger
  parameters:
    ccThreshold: threshold * 0.8
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/gr-advoqpsk/examples/ieee80211_oqpsk_sig_30.bin
    repeat: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [advoqpsk_decode_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [advoqpsk_divider_0, '0', advoqpsk_decode_0, '0']
- [advoqpsk_divider_0, '0', advoqpsk_precfofix_0, '0']
- [advoqpsk_divider_0, '0', advoqpsk_precfofix_1, '0']
- [advoqpsk_divider_0, '0', advoqpsk_sync_0, '0']
- [advoqpsk_divider_0, '1', advoqpsk_powerstep_0, '0']
- [advoqpsk_powerstep_0, '0', advoqpsk_sync_0, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_0, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_1, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_2, '1']
- [advoqpsk_powerstep_0, '0', advoqpsk_trigger_3, '1']
- [advoqpsk_precfofix_0, '0', advoqpsk_trigger_0, '0']
- [advoqpsk_precfofix_0, '1', advoqpsk_trigger_1, '0']
- [advoqpsk_precfofix_1, '0', advoqpsk_trigger_2, '0']
- [advoqpsk_precfofix_1, '1', advoqpsk_trigger_3, '0']
- [advoqpsk_sync_0, '0', advoqpsk_decode_0, '1']
- [advoqpsk_sync_0, '1', advoqpsk_decode_0, '2']
- [advoqpsk_trigger_0, '0', advoqpsk_sync_0, '2']
- [advoqpsk_trigger_1, '0', advoqpsk_sync_0, '3']
- [advoqpsk_trigger_2, '0', advoqpsk_sync_0, '4']
- [advoqpsk_trigger_3, '0', advoqpsk_sync_0, '5']
- [blocks_file_source_0, '0', advoqpsk_divider_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
